# Keil uVision project project.uvprojx, settings and files
target STM32F429-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: uC99=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,STM32F4XX,__ASSEMBLY__,KEIL_IDE,TM_DISCO_STM32F429_DISCOVERY
  c include: .\User;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\src;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F429_LIBRARIES;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\TM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Startup
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STD_Periph_Drivers
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_ltdc.c stm32f4xx_fmc.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_i2c.c
    ./: stm32f4xx_rng.c
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_delay.h tm_stm32f4_delay.c tm_stm32f4_disco.h tm_stm32f4_disco.c tm_stm32f4_l3gd20.c tm_stm32f4_l3gd20.h tm_stm32f4_spi.c tm_stm32f4_spi.h tm_stm32f4_ili9341_ltdc.c tm_stm32f4_ili9341_ltdc.h tm_stm32f4_fonts.c tm_stm32f4_fonts.h tm_stm32f4_sdram.c tm_stm32f4_sdram.h tm_stm32f4_gpio.c tm_stm32f4_gpio.h tm_stm32f4_dma2d_graphic.c tm_stm32f4_dma2d_graphic.h tm_stm32f4_stmpe811.c tm_stm32f4_i2c.c tm_stm32f4_spi_dma.c tm_stm32f4_dma.c tm_stm32f4_spi_dma.h tm_stm32f4_stmpe811.h tm_stm32f4_dma.h tm_stm32f4_i2c.h
    ./: tm_stm32f4_rng.c tm_stm32f4_rng.h
  group User
    ./User/: main.h main.c defines.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
